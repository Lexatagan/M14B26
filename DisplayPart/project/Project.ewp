# IAR project Project.ewp, settings and files
configuration HY_STM32MINI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: VECT_TAB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER; USE_HY_STM32MINI; LAN_DEVICE; nADEBUG
  ICCARM.CCIncludePath2: ..\include; ..\FWLib\library\inc; ..\TMetLib\inc; ..\Interface\inc; ..\RS485\inc; ..\LCDLib\inc; ..\DBGLib\inc; ..\UARTLib\library\inc; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VirtualCOMPort.srec
  ILINK.IlinkOutputFile: Result.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application Files
    ../source/: hw_config.c main.c stm32f10x_it.c
  group DBG
    ../DBGLib/src/: DBG.c
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group Interface
    ../Interface/src/: Interface.c
  group LCDLib
    ../LCDLib/src/: fonts.c LCD.c ssd1289.c
  group RS485
    ../RS485/src/: rs485.c
  group STM32F10X/STM32F10X_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group TMetLib
    ../TMetLib/src/: TimeMeter.c
